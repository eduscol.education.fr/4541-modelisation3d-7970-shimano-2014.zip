# Autodesk Inventor assembly: Boitier
## iProperties
Created: 2011-07
Part Number: Boitier
Document SubType Name: Assembly
Designer: domi
Author: domi
