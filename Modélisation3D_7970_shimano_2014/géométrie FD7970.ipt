# Autodesk Inventor part: géométrie FD7970
## iProperties
Created: 2011-11
Part Number: géométrie FD7970
Document SubType Name: Modeling
Designer: Laur
Density: 1 g/cm^3
Author: Laur
