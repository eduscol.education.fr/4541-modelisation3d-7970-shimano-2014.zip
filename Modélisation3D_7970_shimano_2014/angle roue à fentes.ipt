# Autodesk Inventor part: angle roue à fentes
## iProperties
Created: 2011-11
Part Number: angle roue à fentes
Document SubType Name: Modeling
Designer: Laur
Density: 1 g/cm^3
Author: Laur
