# Autodesk Inventor assembly: méca Dura Ace
## iProperties
Created: 2011-11
Part Number: méca Dura Ace
Document SubType Name: Assembly
Designer: Laur
Author: Laur
