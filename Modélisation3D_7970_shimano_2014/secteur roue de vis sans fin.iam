# Autodesk Inventor assembly: secteur roue de vis sans fin
## iProperties
Created: 2011-10
Part Number: secteur roue de vis sans fin
Document SubType Name: Assembly
Designer: Laur
Author: Laur
