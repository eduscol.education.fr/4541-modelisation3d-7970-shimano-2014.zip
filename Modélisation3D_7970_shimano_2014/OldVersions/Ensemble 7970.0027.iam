# Autodesk Inventor assembly: Ensemble 7970
## iProperties
Created: 2011-10
Part Number: Ensemble 7970
Document SubType Name: Assembly
Designer: Laur
Author: Laur
