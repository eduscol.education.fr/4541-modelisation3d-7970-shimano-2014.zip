# Autodesk Inventor assembly: roue de vis sans fin
## iProperties
Created: 2011-07
Part Number: roue de vis sans fin
Document SubType Name: Assembly
Designer: Laur
Author: Laur
